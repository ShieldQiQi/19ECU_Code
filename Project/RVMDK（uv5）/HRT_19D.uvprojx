# Keil uVision project HRT_19D.uvprojx, settings and files
target ECU (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HRT_18D_ECU +hex
  c flags: Optim=2 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\User\Timer;..\..\User\Encoder;..\..\User\ADC_DMA;..\..\User\can;..\..\User\usart;..\..\User\led;..\..\User\Brake_Led;..\..\User\Beep;..\..\User\ASSI;..\..\User\ASMS;..\..\User\BACKUP_IO;..\..\User\Msg_queue;..\..\User\Circult;..\..\User\pid;..\..\User\nvic;..\..\User\rtc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c
    ../../User/Timer/: timer.c
    ../../User/ADC_DMA/: adc.c
    ../../User/can/: can.c
    ../../User/led/: led.c
    ../../User/usart/: debug_usart.c
    ../../User/Beep/: beep.c
    ../../User/Brake_Led/: brake_led.c
    ../../User/ASMS/: asms.c
    ../../User/ASSI/: assi.c
    ../../User/Circult/: circult.c
    ../../User/BACKUP_IO/: bckp_io.c
    ../../User/Msg_queue/: msg_queue.c
    ../../User/pid/: pid.c
    ../../User/nvic/: nvic.c
    ../../User/rtc/: rtc.c
  group HRT_19D
    ../../HRT_18D/: Readme_Tech.txt
    ../../: Record.txt
